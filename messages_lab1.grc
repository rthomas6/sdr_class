<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>messages_lab1</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>1000</value></param>
<param><key>label</key><value>Period [ms]</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>msg_debug</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>pdu_gen</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>100</value></param>
<param><key>minsize</key><value>20</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>trigger</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>period</value></param>
</block>
<connection><source_block_id>pdu_gen</source_block_id><sink_block_id>msg_debug</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>trigger</source_block_id><sink_block_id>pdu_gen</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
</flow_graph>
